# Keil uVision project STC_USB_CV.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Workspace;.\Workspace\Include
  group Source Group 1
    ./: STARTUP.A51
    ./Workspace/Code/: INA219.c io.c mian.c OLED.c
  group Read
    ./Workspace/Read/: read.txt
